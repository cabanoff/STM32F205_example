# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx
  ICCARM.CCIncludePath2: ../common; Inc; ../common/Drivers/STM32F2xx_HAL_Driver/Inc; ../common/Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../common/Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../common/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.srec
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkKeepSymbols: APP
  ILINK.IlinkIcfFile: stm32F205xx_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ../common/: startup_stm32f205xx.s
  group Application/Inc
    Inc/: crc.h enterID.h flash.h gpio.h main.h stm32f2xx_hal_conf.h stm32f2xx_it.h uart.h xmodem.h
  group Application/User
    Src/: alarm.c crc.c eeprom.c flash.c gpio.c stm32f2xx_hal_msp.c stm32f2xx_it.c uart.c xmodem.c
    ./: bootloader_main.c
  group Drivers/CMSIS
    Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../common/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_wwdg.c
  group Linker
    ./: stm32F205xx_bootloader.icf
